# Keil uVision project Firmware-24-802-ALL.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Firmware-24-802-ALL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\Code;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Code
    ./Code/: main.c app-elv.c app-dss.c
  group Library
    ./Library/: compile-options.h lib-rcc.c lib-rcc.h lib-smart-servo.c lib-smart-servo.h lib-pwm-servo.c lib-pwm-servo.h lib-driver-gpio.c lib-driver-gpio.h lib-driver-spi.c lib-driver-spi.h lib-quadrature-enc.c lib-quadrature-enc.h lib-limit-switch.c lib-limit-switch.h lib-board.c lib-board.h lib-comms.c lib-comms.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.4.2
